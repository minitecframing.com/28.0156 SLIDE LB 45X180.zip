# Autodesk Inventor assembly: 28.0156 SLIDE LB 45X180
## iProperties
Created: 2007-06
Part Number: 28.0156 SLIDE LB 45X180
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
